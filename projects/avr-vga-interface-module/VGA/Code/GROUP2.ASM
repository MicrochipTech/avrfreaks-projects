GROUP_2:
CPI R20,0x20
BREQ DO_PC
CPI R20,0x21
BREQ DO_CP
CPI R20,0x22
BREQ DO_CM
CPI R20,0x23
BREQ DO_FORE
CPI R20,0x24
BREQ DO_BACK
CPI R20,0x25
BREQ DO_TEXT_AREA
RJMP COMMAND_MODE

DO_PC:
LD R16,Z+	;load character code
RCALL PUT_CHAR
RJMP COMMAND_MODE

DO_CP:
LD XL,Z+	;load XL
LD XH,Z+	;load XH
LD YL,Z+	;load YL
LD YH,Z+	;load YH
RCALL CURSOR_POSITION
RJMP COMMAND_MODE

DO_CM:
LD R16,Z+	;load CODE
STS CHAR_MODE,R16
RJMP COMMAND_MODE

DO_FORE:
LD R16,Z+	;load COLOR
STS FORECOLOR,R16
RJMP COMMAND_MODE

DO_BACK:
LD R16,Z+	;load COLOR
STS BACKCOLOR,R16
RJMP COMMAND_MODE

DO_TEXT_AREA:
LD XL,Z+	;load XL
LD XH,Z+	;load XH
LD YL,Z+	;load YL
LD YH,Z+	;load YH
LD R16,Z+	;load LENGTH_L
LD R17,Z+	;load LENGTH_H
LD R18,Z+	;load HEIGHT_L
LD R19,Z+	;load HEIGHT_H
RCALL TEXT_AREA
RJMP COMMAND_MODE