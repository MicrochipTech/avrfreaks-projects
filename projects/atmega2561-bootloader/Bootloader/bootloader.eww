<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Test\test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Test_USART\Test_USART.ewp</path>
  </project>
  <batchBuild/>
</workspace>


