# IAR project ckup (3) of bootloader.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkcan128s.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: bl_can.c bl_can.h boot.h bootloader.c bootloader.h common.h leds.c leds.h lnkcan128s.xcl mem_settings.h queue.c queue.h usart.c usart.h
