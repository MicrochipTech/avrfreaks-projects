# IAR project common_applications_os_examples_event_evk1105.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1105
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..\..\conf_event; ..\..\..\..\..\utils\preprocessor; ..\..\..\..\..\drivers\tc; ..\..\..\..\..\drivers\cpu\cycle_counter; ..\..\..\..\..\boards; ..\..\..\os; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\common\boards; ..; ..\..\..\..\..\boards\evk1105; ..\..\..\os\port\avr32_uc3; ..\..\..\..\..\drivers\rtc; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\drivers\gpio; ..\..\..\..\..\drivers\pm; ..\..\..\..\..\drivers\flashc; ..\..\..\..\..\utils; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1105
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\utils\linker_scripts\at32uc3a\0512\iar\lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/applications/asf_os/os
    ../../../os/: os_core.c os_semaphore.c os_interrupt.c os_debug.c os_event.c os_queue.c os_task.c os_mutex.c os_statistics.c
  group avr32/applications/asf_os/os/port/avr32_uc3
    ../../../os/port/avr32_uc3/: uc3_port.c
  group avr32/applications/asf_os/examples
    ../../: event.c
  group avr32/drivers/pm
    ../../../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/gpio
    ../../../../../drivers/gpio/: gpio.c
  group avr32/drivers/rtc
    ../../../../../drivers/rtc/: rtc.c
  group avr32/drivers/tc
    ../../../../../drivers/tc/: tc.c
  group avr32/drivers/flashc
    ../../../../../drivers/flashc/: flashc.c
  group avr32/boards/evk1105
    ../../../../../boards/evk1105/: init.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
  group common/services/clock/uc3a0_a1
    ../../../../../../common/services/clock/uc3a0_a1/: sysclk.c
