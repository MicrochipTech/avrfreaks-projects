<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_applications_os_examples_event_evk1105.ewp</path>
	</project>
</workspace>
